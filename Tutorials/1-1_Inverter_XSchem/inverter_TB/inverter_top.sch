v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 280 -420 300 -420 {
lab=A}
N 470 -420 490 -420 {
lab=Y}
C {/home/goodkook/ETRI050_DesignKit/Tutorials/1-1_Inverter_XSchem/inverter.sym} 120 -130 0 0 {name=X1}
C {gnd.sym} 380 -360 0 0 {name=l1 lab=GND}
C {vdd.sym} 380 -480 0 0 {name=l2 lab=VDD}
C {ipin.sym} 280 -420 0 0 {name=p3 lab=A}
C {opin.sym} 490 -420 0 0 {name=p1 lab=Y}
