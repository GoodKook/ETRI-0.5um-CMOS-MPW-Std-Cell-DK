v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {/home/goodkook/ETRI050_DesignKit/Tutorials/1-3_Inverter_Netgen/buffer.sym} -90 60 0 0 {name=X1}
